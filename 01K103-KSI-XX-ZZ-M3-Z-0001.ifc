Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 2783626e-cb6d-42ec-9cc3-ba83a284592e, NumberOfSaves: 10], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: 01K103-KSI-XX-ZZ-M3-Z-0001.ifc
Time: 2025-06-10T11:39:04+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Kingspan Kooltherm® K103

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcBuildingElementProxy: Model Text:600mm KI_CenturyGothic (13)
In: Level 0
Pset_BuildingElementProxyCommon - Reference: 600mm KI_CenturyGothic; sets with these values: 2
Name (Model Text:600mm KI_CenturyGothic:...)
305753
307203
307232
307240
307271
307279
307287
307295
307325
307333
307341
307349
307357

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-100, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-100:307948
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-100 100 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-100; TotalThickness: 100 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-100

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-120, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-120:307955
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-120 120 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-120; TotalThickness: 120 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-120

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-130, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-130:307962
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-130 130 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-130; TotalThickness: 130 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-130

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-140, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-140:307969
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-140 140 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-140; TotalThickness: 140 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-140

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-150, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-150:308012
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-150 150 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-150; TotalThickness: 150 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-150

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-25, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-25:307176
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-25 25 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-25; TotalThickness: 25 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-25

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-40, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-40:307478
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-40 40 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-40; TotalThickness: 40 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-40

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-50, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-50:307492
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-50 50 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-50; TotalThickness: 50 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-50

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-60, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-60:307888
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-60 60 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-60; TotalThickness: 60 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-60

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-70, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-70:307895
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-70 70 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-70; TotalThickness: 70 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-70

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-75, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-75:307902
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-75 75 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-75; TotalThickness: 75 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-75

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-80, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-80:307934
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-80 80 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-80; TotalThickness: 80 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-80

# IfcCovering: Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-90, Floor:KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-90:307941
In: Level 0
Type - PredefinedType: FLOORING; Material: KingspanInsulation01GB_Insulation_Kooltherm-K103-Floorboard-90 90 mm
Type - Pset_ConcreteElementGeneral - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_CoveringCommon - FireRating: To BS EN 13501-1: 2018, Euroclass RtF C-s2,d0
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-90; TotalThickness: 90 mm
Pset_QuantityTakeOff - Reference: KingspanInsulation_Insulation_Kooltherm-K103-Floorboard-90
